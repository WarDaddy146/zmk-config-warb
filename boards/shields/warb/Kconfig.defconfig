## boards/shields/warb/Kconfig.defconfig
```kconfig
if SHIELD_WARB

config ZMK_KEYBOARD_NAME
    default "warb"

endif # SHIELD_WARB
```
